# Keil uVision project HY-F407.uvprojx, settings and files
target YH (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HY-F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\Bsp;..\User\Sys;..\FreeRTOS\include;..\FreeRTOS\portable;..\FreeRTOS;..\User\Bsp\fire_phoenix_esc;..\User\Bsp\ad_sensor;..\User\Bsp\PH_sensor;..\User\Bsp\JXCT_TDS;..\User\Bsp\adc;..\DSPLIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group START
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/Sys/: sys.c
    ../User/Bsp/: ship_route.c cyc_list.c primx.c
    ../DSPLIB/: arm_cortexM3l_math.lib
  group BSP
    ../User/Bsp/: bsp_SysTick.c bsp_Flash.c bsp_debug_usart.c bsp_IOT_BC20.c bsp_Led.c bsp_Sensors.c bsp_Compass.c DEV_IIC.c iwdg.c
    ../User/Bsp/fire_phoenix_esc/: fire_phoenix_esc.c
    ../User/Bsp/ad_sensor/: NTU.c battery.c water.c HC_SR04.c dht11.c IIC.c BMP280.c light.c
    ../User/Bsp/adc/: bsp_adc.c
    ../User/Bsp/JXCT_TDS/: JXCT_TDS.c
    ../User/Bsp/PH_sensor/: PH_sensor.c
  group RTOS_CORE
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/: stream_buffer.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group RTOS_MEM
    ../FreeRTOS/portable/: heap_4.c
    ../FreeRTOS/: FreeRTOSConfig.h
